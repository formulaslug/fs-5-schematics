# Repository formulaslug/fs-5-schematics (continued)

## KiCad design test-module-temp-sense-board/test-module-temp-sense-board.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: 1 uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX5R8BB105; Digi PN 311-1445-1-ND
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J5: FH34SRJ-12S-0.5SH(50); FPC-12PIN-CABLE-P0.5mm-W0.3mm
J6: FH12-12S-1SH(55); FPC-12PIN-CABLE-P1mm-W0.65mm
J7: 1-84953-2; FPC-12PIN-CABLE-P1mm-W0.71mm
R1, R2: 5k; R_0603_1608Metric
TP1, TP2, TP3, TP4, TP8, TP9, TP10, TP11, TP15, TP16, TP17, TP18: TestPoint; TestPoint_Pad_D1.0mm
U1, U2, U3, U4, U5, U6: TMP1075D; SO-8_3.9x4.9mm_P1.27mm; MFG PN TMP1075DR; Digi PN 296-51833-1-ND

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, J5.4, J6.4, J7.4, R1.1, R2.1, U1.8 (V+), U2.7 (A0), U2.8 (V+), U3.6 (A1), U3.7 (A0), U3.8 (V+), U4.8 (V+), U5.7 (A0), U5.8 (V+), U6.7 (A0), U6.8 (V+)
/SCL: J5.2, J6.2, J7.2, R2.2, U1.2 (SCL), U2.2 (SCL), U3.2 (SCL), U4.2 (SCL), U5.2 (SCL), U6.2 (SCL)
/SDA: J5.3, J6.3, J7.3, R1.2, U1.1 (SDA), U2.1 (SDA), U3.1 (SDA), U4.1 (SDA), U5.1 (SDA), U6.1 (SDA)
/v0: H4.1 (1_1), J5.8, J6.8, J7.8
/v1: H1.1 (1_1), J5.7, J6.7, J7.7
/v2: H3.1 (1_1), J5.6, J6.6, J7.6
/v3: H2.1 (1_1), J5.5, J6.5, J7.5
unnamed: J5.9, TP4.1 (1_1)
unnamed: J5.10, TP3.1 (1_1)
unnamed: J5.11, TP2.1 (1_1)
unnamed: J5.12, TP1.1 (1_1)
unnamed: J6.9, TP11.1 (1_1)
unnamed: J6.10, TP10.1 (1_1)
unnamed: J6.11, TP9.1 (1_1)
unnamed: J6.12, TP8.1 (1_1)
unnamed: J7.9, TP18.1 (1_1)
unnamed: J7.10, TP17.1 (1_1)
unnamed: J7.11, TP16.1 (1_1)
unnamed: J7.12, TP15.1 (1_1)
V-: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J5.1, J6.1, J7.1, U1.4 (GND), U1.5 (A2), U1.6 (A1), U1.7 (A0), U2.4 (GND), U2.5 (A2), U2.6 (A1), U3.4 (GND), U3.5 (A2), U4.4 (GND), U4.5 (A2), U4.6 (A1), U4.7 (A0), U5.4 (GND), U5.5 (A2), U5.6 (A1), U6.4 (GND), U6.5 (A2), U6.6 (A1)

Notes on the sheet:
Hirose also has a top & bottom contact version (FH34D) if we think that'd be better
Alternate Datasheet Link
2 layer board

Board: 2 copper layers, 144.4 x 133.8 mm, 33 parts (1 on the bottom side), 20 nets.

## KiCad design test-module-busbar-board/test-module-busbar-board.kicad_pcb

Board: 2 copper layers, 142.6 x 70.4 mm, 8 parts (0 on the bottom side), 4 nets.

Parts:
F1, F2, F3, F4: Littlefuse 1812L050/30; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
H1, H2, H3, H4: 24939

Connections:
/cell_0_fused: F3.2, H3.1
/cell_0_minus_fused: F4.2, H4.1
/cell_1_fused: F2.2, H2.1
/cell_2_fused: F1.2, H1.1
