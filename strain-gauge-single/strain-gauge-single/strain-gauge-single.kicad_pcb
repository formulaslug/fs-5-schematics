# Repository formulaslug/fs-5-schematics (continued)

## KiCad design tractive-battery-board/tractive-battery-board.kicad_pcb

Parts:
C1, C2: 6.8pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603CRNPO9BN6R8; Digi PN 311-3861-1-ND
C3, C6, C7, C8, C9, C10, C11, C13, C14, C15, C16, C17, C18, C19, C20, C25, C26: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
C4: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CL21A475KAQNNNE; Digi PN 1276-1244-1-ND
C5, C23: 10uF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN CL21A106KAYNNNE; Digi PN 1276-2891-1-ND
C12, C22, C24: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB105; Digi PN 311-1802-1-ND
C21: 15nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB153; Digi PN 311-4080-1-ND
C27: 47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CL21A476MQYNNNE; Digi PN 1276-1852-1-ND
D1, D2, D3, D4, D5, D6: PLZ3V3B-G3/H; D_SMF; MFG PN PLZ3V3B-G3/H; Digi PN PLZ3V3B-G3/HGIDKR-ND
FB1: FCM 1608KF-601T03; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MFG PN FCM 1608KF-601T03; Digi PN 4816-FCM1608KF-601T03CT-ND
H1, H2: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: FTSH-107-01-F-DV-K-P-TR; PinHeader_2x07_P1.27mm_Vertical_SMD; MFG PN FTSH-107-01-F-DV-K-P-TR; Digi PN SAM13170CT-ND
J2: IMD_Connector; 1054311103 - 3-Pin Molex Nano-fit
J3: Busbar_Temp_Sense; 1054311202 - 2-Pin Molex Nano-fit
J4: Cooling_TS; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
J5: E-Meter; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
J6: BMS_TS; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
J7: Conn_02x13_Counter_Clockwise; VQFN24_RGE_TEX; MFG PN ATS15-26PA-BM01; Digi PN 889-ATS15-26PA-BM01-ND
J15: IMD_CAN; 1054311202 - 2-Pin Molex Nano-fit
JP1: Jumper_2_Open; PinHeader_2x01_P2.54mm_Vertical; MFG PN M20-9990246; Digi PN 952-2262-ND
L1: 4.7uH; L_Bourns_SRP5030T; MFG PN SRP5030T-4R7M; Digi PN SRP5030T-4R7MCT-ND
Q1: AO3400A; SOT-23; MFG PN AO3400A; Digi PN 785-1000-1-ND
Q2: AO3401A; SOT-23; MFG PN AO3401A; Digi PN 785-1001-1-ND
R1, R2, R24, R25, R28: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R3, R4: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-07120RL; Digi PN 311-120HRCT-ND
R5, R7, R10, R12: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0720KL; Digi PN 311-20.0KHRCT-ND
R6, R8, R11, R13: 6.8k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-076K8L; Digi PN YAG3627CT-ND
R9, R22, R23: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-13100KL; Digi PN 13-AC0603FR-13100KLCT-ND
R14, R15, R16, R17, R18, R29: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0715KL; Digi PN 311-15.0KHRCT-ND
R19: 1.3k; R_2010_5025Metric_Pad1.40x2.65mm_HandSolder; MFG PN AC2010FK-071K3L; Digi PN YAG4005CT-ND
R20: 330; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; MFG PN RC1206JR-07330RL; Digi PN 311-330ERCT-ND
R21: 560; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; MFG PN RC1206FR-07560RL; Digi PN 311-560FRCT-ND
R26: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-074K7L; Digi PN YAG3613CT-ND
R27: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-075K1L; Digi PN 311-5.10KHRCT-ND
SW1: Y97KT23B5NAFP; SW_SPST_PTS647_Sx38; MFG PN Y97KT23B5NAFP; Digi PN 108-Y97KT23B5NAFPCT-ND
SW2: SW_Push; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
TP1: MISO_TP; TestPoint_Pad_D1.0mm
TP2: MOSI_TP; TestPoint_Pad_D1.0mm
TP3: SCK_TP; TestPoint_Pad_D1.0mm
TP4: CK_TP; TestPoint_Pad_D1.0mm
TP16: PC13_TP; TestPoint_Pad_D1.0mm
TP17: PC14_TP; TestPoint_Pad_D1.0mm
TP18: PC15_TP; TestPoint_Pad_D1.0mm
TP19: PC7_TP; TestPoint_Pad_D1.0mm
TP20: PC8_TP; TestPoint_Pad_D1.0mm
TP21: PC3_TP; TestPoint_Pad_D1.0mm
TP22: PC2_TP; TestPoint_Pad_D1.0mm
TP23: PC1_TP; TestPoint_Pad_D1.0mm
TP24: PA4_TP; TestPoint_Pad_D1.0mm
TP25: PB8_TP; TestPoint_Pad_D1.0mm
TP26: PC6_TP; TestPoint_Pad_D1.0mm
TP27: PC5_TP; TestPoint_Pad_D1.0mm
U1: STLINK-V3MODS; MODULE_STLINK-V3MODS; PARTREV 1
U2: STM32G473RBT6; LQFP-64_10x10mm_P0.5mm; MFG PN STM32F446RET6; Digi PN 497-15376-ND
U3, U4: ISO1044BD; SOIC-8_3.9x4.9mm_P1.27mm
U5: DS18B20Z+; SOIC-8_3.9x4.9mm_P1.27mm; MFG PN DS18B20Z+; Digi PN DS18B20Z+-ND
U6: MIC5504-3.3YM5; SOT-23-5; MFG PN MIC5504-3.3YM5-TR; Digi PN 576-4764-1-ND
U7: AP63205WU; TSOT-23-6; MFG PN AP63205WU-7; Digi PN AP63205WU-7DICT-ND
Y1: ECS-240-8-37B-CKY-TR; Crystal_SMD_2016-4Pin_2.0x1.6mm; MFG PN ECS-240-8-37B-CKY-TR; Digi PN XC3063CT-ND

Connections:
+3V3: C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C24.2, FB1.1, J1.3, Q2.3 (D), R26.1, U1.30 (T_VCC), U2.1 (VBAT), U2.16 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U3.1 (VCC1), U4.1 (VCC1), U6.5 (VOUT); also elsewhere on the board
+3V3_A: C12.1, C13.1, FB1.2, U2.29 (VDDA)
+5V: C14.1, C15.1, C22.2, C27.2, J7.26, L1.2, R25.1, SW2.1, U1.22 (5V_OPT), U3.8 (VCC2), U4.8 (VCC2), U6.1 (VIN), U6.3 (EN), U7.1 (FB); also elsewhere on the board
+12V: C23.2, J2.2, J7.1, R5.2, U7.2 (EN), U7.3 (IN); also elsewhere on the board
/BOOT0: R1.1, U2.2 (PC13)
/IMD_FAULT_12V: J2.1, R19.1
/OSC_IN: C1.1, U2.5 (RCC_OSC_IN), Y1.3
/OSC_OUT: C2.1, U2.6 (RCC_OSC_OUT), Y1.1
/Shutdown + IMD Delay/BMS_FAULT_5V: Q1.3 (D), R25.2; also elsewhere on the board
/nIMD_FAULT_5V: R19.2, R20.1; also elsewhere on the board
CAN_2_RD: U2.34 (FDCAN2_RX), U3.3 (RXD)
CAN_2_TD: U2.35 (FDCAN2_TX), U3.2 (TXD)
CAN_H_1: J7.3, J7.5, U4.6 (CANH)
CAN_H_2: J7.14, J7.17, J15.4, U3.6 (CANH)
CAN_L_1: J7.4, R4.2, U4.5 (CANL)
CAN_L_2: J7.15, J15.3, R3.2, U3.5 (CANL)
CAN_L_RES_1: J7.6, R4.1
CAN_L_RES_2: J7.16, R3.1
CAN_POWERTRAIN_RD: U2.61 (FDCAN1_RX), U4.3 (RXD)
CAN_POWERTRAIN_TD: U2.62 (FDCAN1_TX), U4.2 (TXD)
Charge_State: J7.24, R9.1, R14.1
Charge_State_Filtered: C16.1, D3.1 (K), R14.2, U2.26 (PB2)
Fan_PWM: J7.7, U2.38 (PC6)
GLV_Voltage: C17.1, D1.1 (K), R15.2, U2.36 (PB14)
IMD_Fault_3V3: C21.1, D6.1 (K), R22.2, TP27.1, U2.11 (PC3), U2.39 (PC7)
IRs_Final: J7.20, R7.2; also elsewhere on the board
NRST: C3.2, J1.12, SW1.2, U1.31 (T_NRST), U2.7 (PG10)
unnamed: J4.1, J5.1, J6.1, JP1.1 (A)
unnamed: J7.18, J15.1
unnamed: J7.21, J15.2
unnamed: Q1.1 (G), R24.1
unnamed: R10.1, R11.2, R17.1
unnamed: R12.1, R13.2, R18.1
unnamed: R5.1, R6.2, R15.1
unnamed: R7.1, R8.2, R16.1
unnamed: R20.2, R21.1, R22.1
unnamed: R27.2, R28.2, R29.1
unnamed: TP22.1, U2.53 (PC11)
unnamed: TP23.1, U2.54 (PC12)
unnamed: TP24.1, U2.51 (PA15)
unnamed: TP25.1, U2.30 (PB10)
unnamed: TP26.1, U2.3 (PC14)
unnamed: TP20.1 (1_1), U2.12 (PA0)
unnamed: TP19.1 (1_1), U2.13 (PA1)
unnamed: TP16.1 (1_1), U2.8 (PC0)
unnamed: TP17.1 (1_1), U2.40 (PC8)
unnamed: TP18.1 (1_1), U2.41 (PC9)
unnamed: C25.2, U7.6 (BST)
unnamed: C25.1, L1.1, U7.5 (SW)
SH_RESET-: J7.25, R27.1, SW2.2
SH_RESET_3V3: C26.1, R29.2, U2.43 (PA9), U2.58 (PB5)
SPI_BMS_CS: TP4.1 (1_1), U2.57 (SPI1_MISO); also elsewhere on the board
SPI_MISO: TP1.1 (1_1), U2.20 (SPI1_MISO); also elsewhere on the board
SPI_MOSI: TP2.1 (1_1), U2.21 (SPI1_MOSI); also elsewhere on the board
SPI_SCK: TP3.1 (1_1), U2.52 (SPI3_SCK); also elsewhere on the board
STLINK_SWCLK: J1.6, U1.13 (T_JCLK/T_SWCLK), U2.50 (SYS_JTCK-SWCLK)
STLINK_SWDIO: J1.4, U1.4 (T_JTMS/T_SWDIO), U2.49 (SYS_JTMS-SWDIO)
STLINK_SWO: J1.8, U1.6 (T_JTDO/T_SWO), U2.56 (SYS_JTDO-SWO)
Shutdown_In: J7.23, R10.2; also elsewhere on the board
Shutdown_In_3V3_Filtered: C19.1, D4.1 (K), R17.2, U2.24 (PB0)
Shutdown_Measure: C18.1, D2.1 (K), R16.2, U2.33 (PB11)
Shutdown_Out: J7.22, R12.2; also elsewhere on the board
Shutdown_Out_3V3_Filtered: C20.1, D5.1 (K), R18.2, U2.25 (PB1)
TS1W: J3.1, JP1.2 (B), Q2.2 (S), R26.2, U2.19 (PA5), U5.4 (DQ)
TS1W_PU_Control: Q2.1 (G), U2.18 (PA4)
TS_READY: J7.19, U2.9 (PC1)
VCP_UART_RX: J1.13, U1.15 (T_VCP_RX), U2.17 (USART2_RX)
VCP_UART_TX: J1.14, U1.12 (T_VCP_TX), U2.14 (USART2_TX)
V_Curr_Out: J7.8; also elsewhere on the board
V_Curr_Ref: J7.9; also elsewhere on the board
V_Out_Negative: J7.10, U2.22 (PC4); also elsewhere on the board
V_Out_Positive: J7.11, U2.23 (PC5); also elsewhere on the board
nBMS_FAULT_VCU: J7.12; also elsewhere on the board
nBMS_Fault_3V3: R23.2, R24.2, U2.10 (PC2)
nIMD_FAULT_VCU: J7.13; also elsewhere on the board
nPreCharge_Control: U2.42 (PA8); also elsewhere on the board

Notes on the sheet:
E-Meters
add buffer to ts ready
include diagraam for IRs
Auxillary Connectors
STM32F446RETx MCU
Shutdown + IMD Delay
~100Hz RC Filter
Decoupling 100nF capacitors need to be placed as close to respective Vdd/Vss as possible. Note that VSS contains all VSS mcu pins for each VDD/VSS pair.
TB Board Mount E-Meter
NOTE: CAN Bridge left disconnected for now, but if we can figure out the protocol on the usb side to access it, we can connect it
IsoSPI
CAN Transciever
MCU Protections
HV Voltage Indicator
Current Sensor + Filtering
ST-Link Programming/Debugging Connector
source digikey part
SH_Reset
SH_RESET+
STLINKV3-MODS Programmer
24MHz
Power Block
Precharge Circuit

Parts:
C28, C29: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
C30: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603JRNPO9BN150; Digi PN 311-1060-1-ND
C31: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KPX7R8BB103; Digi PN 13-CC0603KPX7R8BB103CT-ND
J8: IsoSPI; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
L2: HM2113ZNL; L_CommonModeChoke_TDK_ACM2520-3P; MFG PN HM2113ZNLT; Digi PN 553-HM2113ZNLTCT-ND
R30: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-072K2L; Digi PN 311-2.20KHRCT-ND
R31: 1.5K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-071K5L; Digi PN 311-1.50KHRCT-ND
R32: 680; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-07680RL; Digi PN 311-680HRCT-ND
R33: 402; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07402RL; Digi PN 13-AC0603FR-07402RLCT-ND
R34: 220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-07220RL; Digi PN 311-220HRCT-ND
R35, R36: 22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0722RL; Digi PN 311-22.0HRCT-ND
TP5: IsoSPI_P; TestPoint_Pad_D1.0mm
TP6: IsoSPI_N; TestPoint_Pad_D1.0mm
U8: LTC6820; MSOP-16_3x4.039mm_P0.5mm; MFG PN LTC6820HMS#3ZZTRPBF; Digi PN 505-LTC6820HMS#3ZZTRPBFCT-ND

Connections:
+3V3: C28.1, C29.1, R30.2, U8.1 (EN), U8.6 (V_DDS), U8.9 (V_DD), U8.12 (MSTR); also elsewhere on the board
/IsoSPI/IBIAS: R31.1, U8.16 (IBIAS)
/IsoSPI/ICMP: R31.2, R32.1, U8.15 (ICMP)
/IsoSPI/IsoSPI+: L2.4, R33.1, U8.11 (IP)
/IsoSPI/IsoSPI-: C30.2, L2.6, U8.10 (IM)
unnamed: C30.1, R33.2
unnamed: C31.1, L2.5
unnamed: J8.1, R36.2, TP6.1 (1_1)
unnamed: J8.2, R35.2, TP5.1 (1_1)
unnamed: L2.1, R34.2, R36.1
unnamed: L2.3, R34.1, R35.1
SPI_BMS_CS: U8.5 (CS); also elsewhere on the board
SPI_MISO: R30.1, U8.3 (MISO); also elsewhere on the board
SPI_MOSI: U8.2 (MOSI); also elsewhere on the board
SPI_SCK: U8.4 (SCK); also elsewhere on the board

Notes on the sheet:
RB1
RB2
SPI -> IsoSPI Conversion
IsoSPI Filtering and Isolation

Parts:
C41: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
J13: TS; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
J14: HVIL+/HVIL-; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
PS1: TMR_3-7211WIR; TMR 3-7211WIR; MFG PN TMR 3-7211WIR; Digi PN 1951-2005-ND
R50: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0715KL; Digi PN 311-15.0KHRCT-ND
R51, R54: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R52, R53: 145k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN RT0805BRD07145KL; Digi PN 13-RT0805BRD07145KLCT-ND
U17: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
/HVIL/HVIL_P: J14.1, U17.1
/HVIL/TS_P: J13.2, PS1.2 (+VIN(VCC)), R52.1
unnamed: C41.2, PS1.6 (+VOUT), R50.1, U17.4 (V+)
unnamed: R52.2, R53.1
unnamed: R53.2, R54.2, U17.3 (+)
unnamed: R50.2, R51.1, U17.2 (-)
TS_N: C41.1, J13.1, J14.2, PS1.1 (-VIN(GND)), PS1.7 (-VOUT), R51.2, R54.1, U17.11 (V-)

Notes on the sheet:
(TS+)*(1/30)
Opamp chudded, use comparater

Parts:
C36, C37, C39: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
C38: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB105; Digi PN 311-1802-1-ND
C40: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CL10A226MP8NUNE; Digi PN 1276-1274-1-ND
D7, D8, D9, D10, D13: PMEG10020ELR; Nexperia_CFP3_SOD-123W; MFG PN PMEG10020ELR-QX; Digi PN 1727-PMEG10020ELR-QXCT-ND
J10: Shutdown IL; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
K1: G6SK-2G; Relay_DPDT_Omron_G6SK-2G; MFG PN G6SK-2G DC24; Digi PN Z12726-ND
K2, K3, K4: G6DN-1A; RELAY_G6DN-1A; MFG PN G6DN-1A DC12; Digi PN Z5440-ND
R42: 220k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-07220KL; Digi PN YAG3579CT-ND
R43, R46: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-075K1L; Digi PN 311-5.10KHRCT-ND
R44, R47: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R45: 820k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603JR-07820KL; Digi PN 311-820KGRCT-ND
TP7: BMS_DELAY_TP; TestPoint_Pad_D1.0mm
TP8: BMS_FAULT_TP; TestPoint_Pad_D1.0mm
TP9: IMD_DELAY_TP; TestPoint_Pad_D1.0mm
TP10: Post_BSM_TP; TestPoint_Pad_D1.0mm
TP11: IMD_FAULT_TP; TestPoint_Pad_D1.0mm
TP12: Post_IMD_TP; TestPoint_Pad_D1.0mm
U9: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN MCP6004T-I/SL; Digi PN MCP6004T-I/SLCT-ND
U12: SN74HCS14DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HCS14DR; Digi PN 296-SN74HCS14DRDKR-ND
U13: SN74HCS08DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HCS08DR; Digi PN 296-SN74HCS08DRCT-ND
U14, U15: SZNUD3124DMT1G; SC-74-6_1.55x2.9mm_P0.95mm; MFG PN SZNUD3124DMT1G; Digi PN SZNUD3124DMT1GOSCT-ND
U19: 74LS279; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C36.1, C37.1, C39.1, D7.1 (K), D8.1 (K), K1.9, K3.5, R42.1, R43.1, R45.1, R46.1, U9.4 (V+), U12.14 (VCC), U13.14 (VCC); also elsewhere on the board
+12V: D10.1 (K), D13.1 (K), K1.1, K1.4, K1.6, K3.1, K4.1; also elsewhere on the board
/Shutdown + IMD Delay/BMS_FAULT_5V: U13.1; also elsewhere on the board
/Shutdown + IMD Delay/BMS_FAULT_DELAYED: TP8.1 (1_1), U12.1, U13.3, U14.5
/Shutdown + IMD Delay/IMD_FAULT_5V: U12.4, U13.9
/Shutdown + IMD Delay/IMD_FAULT_DELAYED: TP11.1 (1_1), U13.8, U19.6 (~S)
/Shutdown + IMD Delay/nBMS_FAULT_DELAYED_5V: U12.2, U14.2
/nIMD_FAULT_5V: U12.3; also elsewhere on the board
unnamed: C38.1, D7.2 (A), R42.2, TP7.1 (1_1), U9.3 (+)
unnamed: C40.1, D8.2 (A), R45.2, TP9.1 (1_1), U9.5 (+)
unnamed: D9.1 (K), K1.5, K2.1
unnamed: D10.2 (A), D13.2 (A), K3.2, K4.2, U15.3
unnamed: J10.1, K4.8, TP12.1 (1_1)
unnamed: K1.7, U14.3
unnamed: K1.12, U14.6
unnamed: K2.8, K4.5, TP10.1 (1_1)
unnamed: R43.2, R44.2, U9.2 (-)
unnamed: R46.2, R47.2, U9.6 (-)
unnamed: U9.1, U13.2
unnamed: U9.7, U13.10
unnamed: U15.5, U19.7 (Q)
Shutdown_In: K2.5; also elsewhere on the board
Shutdown_Out: J10.2; also elsewhere on the board
nBMS_FAULT_VCU: K1.8; also elsewhere on the board
nIMD_FAULT_VCU: K3.8; also elsewhere on the board

Notes on the sheet:
Outputs High When Fault Detected From BMS
Outputs Low When Fault Detected From IMD
IMD NO Relay
Get rid of relay
15.2 Startup Second Delay
0.2 Startup Second Delay RC = 220k * (1 * 10^-6) = 0.22 sec t = -RC * ln(1 - 3.34/5) = 0.24 seconds
Review Later(maybe rc ciruit)
Can maybe be removed and replaced with mosfet
BMS STARTUP Delay
IMD Delay
BMS NO Relay
Relay Driver Contains internal resistors

Parts:
J11: IRs Power; 1054311104 - 4-pin Molex Nano-fit; MFG PN 1054311104; Digi PN WM26075CT-ND
J12: Precharge; 1054311202 - 2-Pin Molex Nano-fit; MFG PN 1054311102; Digi PN WM26073CT-ND
K5: PR30-12V-450-1A-E; RELAY_PR30-12V-450-1A-E; MFG PN PR30-12V-450-1A-E; Digi PN 2223-PR30-12V-450-1A-E-ND
Q3: AO3400A; SOT-23; MFG PN AO3400A; Digi PN 785-1000-1-ND
R48: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-13100KL; Digi PN 13-AC0603FR-13100KLCT-ND
R49: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
U12: SN74HCS14DR; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN SN74HCS14DR; Digi PN 296-SN74HCS14DRDKR-ND
U16: SZNUD3124LT1G; TSOT-23_HandSoldering; MFG PN SZNUD3124LT1G; Digi PN SZNUD3124LT1GOSCT-ND

Connections:
IRs_Final: J11.2, J11.4, K5.A2; also elsewhere on the board
unnamed: J11.1, Q3.3 (D)
unnamed: J12.1, K5.5
unnamed: J12.2, K5.8
unnamed: K5.A1, U16.3
unnamed: Q3.1 (G), R49.2
unnamed: U12.8, U16.1
nPreCharge_Control: R48.1, R49.1, U12.9; also elsewhere on the board

Notes on the sheet:
nPrecharge_Control outputs LOW during precharge

Parts:
C32, C33: 22nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB223; Digi PN 311-1086-1-ND
C34, C35, C42: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MFG PN CC0603KRX7R8BB104; Digi PN 311-1341-1-ND
D11, D12: PLZ3V3B-G3/H; D_SMF; MFG PN PLZ3V3B-G3/H; Digi PN PLZ3V3B-G3/HGIDKR-ND
J9: Current Sensor; 1054311104 - 4-pin Molex Nano-fit; MFG PN 1054311104; Digi PN WM26075CT-ND
R37: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN AC0603FR-0710KL; Digi PN 311-10KLDCT-ND
R38, R39: 22.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0722K1L; Digi PN 311-22.1KHRCT-ND
R40, R41: 62k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RMCF0603FT62K0; Digi PN RMCF0603FT62K0CT-ND
R55, R56: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0715KL; Digi PN 311-15.0KHRCT-ND
R57: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-0710KL; Digi PN 311-10.0KHRCT-ND
R58: 237k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MFG PN RC0603FR-07237KL; Digi PN 311-237KHRCT-ND
U9, U18: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm; MFG PN MCP6004T-I/SL; Digi PN MCP6004T-I/SLCT-ND
U10, U11: INA826AIDR; SOIC-8_3.9x4.9mm_P1.27mm; MFG PN INA826AIDR; Digi PN 296-30238-1-ND

Connections:
+5V: C34.1, C35.1, C42.1, J9.4, R57.1, U10.8 (V+), U11.8 (V+), U18.4 (V+); also elsewhere on the board
/Current Sensors + Filtering/Raw_Curr_Out: J9.2, R37.1, R38.2
/Current Sensors + Filtering/Raw_Curr_VRef: J9.1, R39.2
unnamed: R40.1, U10.2 (Rg)
unnamed: R40.2, U10.3 (Rg)
unnamed: R41.1, U11.2 (Rg)
unnamed: R41.2, U11.3 (Rg)
unnamed: R55.1, U11.7
unnamed: R56.1, U10.7
unnamed: C32.1, R38.1, U9.10 (+)
unnamed: C33.1, R39.1, U9.12 (+)
unnamed: U10.6 (Ref), U11.6 (Ref), U18.1, U18.2 (-)
unnamed: R57.2, R58.1, U18.3 (+)
V_Curr_Out: U9.8, U9.9 (-), U10.1 (-), U11.4 (+); also elsewhere on the board
V_Curr_Ref: U9.13 (-), U9.14, U10.4 (+), U11.1 (-); also elsewhere on the board
V_Out_Negative: D11.1 (K), R55.2; also elsewhere on the board
V_Out_Positive: D12.1 (K), R56.2; also elsewhere on the board

Notes on the sheet:
GAIN = 1.78 GAIN = 1 + 49.4k/R_G R_G = ~63.333k ohms
swap
0.2 VREF
RC Filter --> 1/(2 * pi * 22,100* 22 * 10^(-9)) = ~327.3Hz
look at tmr
Document and ideal gain. note down theoretical resistor error +- 1% Resistors for the 62k resistor
V_out = 0 < V < 3V3 A = gain = V_out/(V_ref-V_curr_out) = 3.3 / 1.875 = 1.76 (minimum current) V_curr_out = 2.5V + (0.625 * 900A/300A) = 4.375V OR 2.5V + (0.625 * -900A/300A) = 0.625V V_ref = 2.5V + (0.625 * 0A/300A) = 2.5V
10x R, C/10

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
Board: 2 copper layers, 181 parts (0 on the bottom side), 126 nets, no tracks yet.
