# Repository formulaslug/fs-5-schematics

File README.md:

# General Notes

- Clone this repository recursively (`git clone --recursive`). If you didn't, be
  sure to initialize the submodule: `git submodule init` _and_ `git submodule
update`

# Creating a project

1. Install our Template Project to your local computer.
   - Kicad requires templates to be installed locally, but our template is
     stored in the `template` folder in this repo, so you'll need to copy the
     `template` folder to where Kicad expects it. To see where that is, press
     Preferences -> Configure Paths, and look for the value of
     `KICAD_USER_TEMPLATE_DIR`. Copy the `template` folder there.
2. Create a new branch _from main_. Name your branch in-kebab-case
3. Create a new Kicad project from template. Under "User Templates" you should
   now see our Formula Slug template listed! Navigate to `fs-5-schematics` in
   the dialog and name your project the same as your branch name
   (in-kebab-case). This should create a new folder for your project inside of
   `fs-5-schematics`.
5. In the Schematic Editor, open File -> Schematic Setup -> Text Variables, and
   fill in the info for your board.
6. Create an initial commit and get to work!

# LV Standards

https://docs.google.com/document/d/1JF8Ld86JzdSsicxHTWAqBsUBFZuK-cVn7AItZKhkslQ/edit?usp=sharing

# Working with the symbol, footprint, and 3d libraries

Should you have to make any edits (you will!), be sure to follow this procedure:

1. Pull the submodule, to be sure you're working on the latest version: `git submodule update`
2. Make your changes...
3. Commit _to the fs-components_ repo. You can do this with git cli by
   descending into the fs-components directory and using git commands from
   there.
4. Push! Try to do this in the minimum time possible, because if you hold
   changes locally and someone else commits before you, you'll need to redo your
   changes due to merge conflicts.

## KiCad design strain-gauge-single/strain-gauge-single/strain-gauge-single.kicad_pcb

File strain-gauge-single/README.md:

# Single strain gauge measuring Axial forces with radial reference gauge

Board: 4 copper layers, 43.0 x 49.5 mm, 6 parts (0 on the bottom side), 4 nets.

Parts:
C1: 1nF; C_0402_1005Metric
J3: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
R3, R4: 350; R_0402_1005Metric
R5, R6: 100; R_0402_1005Metric

Connections:
Bridge1A_Out: C1.1, J3.3, R6.2
Bridge1B_Out: C1.2, J3.4, R5.2
GND: J3.1, R3.2, R4.2
Gauge: J3.2, R3.1, R4.1, R5.1, R6.1

## KiCad design strain-gauge-single/strain-gauge-single-amplifier-board/strain-gauge-single-amplifier-board.kicad_pcb

Parts:
C2: 10uF; C_0402_1005Metric
C3: 100nF; C_0402_1005Metric
C5: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
FB1: FCM 1608KF-601T03; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Digikey Part Number 4816-FCM1608KF-601T03CT-ND
J1: Out Conn; PinHeader_1x07_P2.54mm_Vertical
J2: Input Conn; PinHeader_1x07_P2.54mm_Vertical
J3, J4, J5, J6: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
U1: MCP3564R-E/ST; MCP3564R-EST
U2: LDK320AM33R; LDK320AM33R-SOT23-5

Connections:
+3V3: FB1.2, U1.20 (DVDD), U2.5 (OUT)
+3V3_A: C2.1, C3.1, FB1.1, J3.2, J4.2, J5.2, J6.2, U1.1 (AVDD), U1.4 (REFIN+/OUT)
+12V: C5.1, J1.6, J2.6, U2.1 (IN), U2.3 (EN)
ADC_CS: J1.1, J2.1, U1.13 (*CS)
Bridge1A_Out: J3.3, U1.5 (CH0)
Bridge1B_Out: J3.4, U1.6 (CH1)
Bridge2A_Out: J4.3, U1.7 (CH2)
Bridge2B_Out: J4.4, U1.8 (CH3)
Bridge3A_Out: J5.3, U1.9 (CH4)
Bridge3B_Out: J5.4, U1.10 (CH5)
Bridge4A_Out: J6.4, U1.12 (CH7)
Bridge4B_Out: J6.3, U1.11 (CH6)
GND: C2.2, C3.2, C5.2, J1.7, J2.7, J3.1, J4.1, J5.1, J6.1, U1.2 (AGND), U1.3 (REFIN-), U1.19 (DGND), U2.2 (GND)
SPI_DRDY: J1.5, J2.5, U1.17 (*IRQ/MDAT)
SPI_MISO: J1.4, J2.4, U1.16 (SDO)
SPI_MOSI: J1.3, J2.3, U1.15 (SDI)
SPI_SCK: J1.2, J2.2, U1.14 (SCK)

Notes on the sheet:
Voltage Regulator
3V3 Filter
+3V3 Regulator
MCP3564R ADC

Board: 4 copper layers, 27.0 x 34.0 mm, 12 parts (0 on the bottom side), 17 nets.

## KiCad design load-slammer/load-slammer.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Manufacturer Part Number CC0603KRX7R9BB104; Digikey Part Number 311-1344-1-ND
C2: 1µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Manufacturer Part Number CGA3E3X7R1H105K080AB; Digikey Part Number 445-CGA3E3X7R1H105K080ABCT-ND
J1, J4: 74651173R; Manufacturer Part Number 74651173R; Digikey Part Number 732-74651173RCT-ND
J2: 1054301102; CONN_SD-105430-001_02_MOL; Manufacturer Part Number 1054301102
J3: 1-1478204-0; BNC_TEConnectivity_1478204_Vertical; Manufacturer Part Number 1-1478204-0
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
Q1: CSD19536KTT; TO-263-2; Manufacturer Part Number CSD19536KTT
R2: 0Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Manufacturer Part Number ERJ-3GEY0R00V; Digikey Part Number P0.0GCT-ND
R3: 10kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Manufacturer Part Number ERJ-3EKF1002V; Digikey Part Number P10.0KHCT-ND
R5: 10kΩ; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder; Manufacturer Part Number CRCW251210K0FKEG; Digikey Part Number 541-10.0KAFCT-ND
R13: 5mΩ; R_Shunt_Ohmite_LVK25; Manufacturer Part Number LVK25R005FER; Digikey Part Number 273-LVK25R005FERCT-ND
R14: 1Ω; TO-247-2_Vertical_P10.16mm; Manufacturer Part Number TEH100M1R00JE
U1: UCC27511ADBV; SOT-23-6; Manufacturer Part Number UCC27511ADBVR

Connections:
/DRV_OUT: R2.1, U1.2 (OUTH), U1.3 (OUTL)
/I_SENSE: J3.1 (In), R13.2
/Q1_DRAIN: Q1.2 (D), R14.2
/Q1_GATE: Q1.1 (G), R2.2, R3.1
/TRIG_IN: J2.1, R5.1, U1.6 (IN+)
GND: C1.2, C2.2, J2.2, J3.2 (Ext), NT1.2, R3.2, R5.2, R13.3, U1.4 (GND), U1.5 (IN-)
GNDPWR: J4.1 (Pin_1_1), NT1.1, R13.4
unnamed: Q1.3 (S), R13.1
PWR_IN: C1.1, C2.1, J1.1 (Pin_1_1), R14.1, U1.1 (V_{DD})

Notes on the sheet:
PWR_IN: 11-14 V from DUT (12 V nominal) Pulsed load: ~12 A per step (~143 W at 12 V; ~14 A, ~195 W at 14 V) stud like connector and screw in connector m4 connector for current
R14 = 1 Ω sets the 25% load step: 25% x 50 A = 12.5 A R_total = 12 V / 12.5 A = 0.96 Ω R14 = 0.96 Ω - Q1 (1.7 mΩ) - R13 (5 mΩ) = 0.953 Ω -> 1 Ω (nearest standard) I = 12 V / 1.007 Ω = 11.9 A (10.9 A at 11 V, 13.9 A at 14 V) P_R14 = 11.9² x 1 Ω = 142 W during a pulse
Switch & Sense
Power
Load Resistor
Gate Control

Board: 2 copper layers, 48.5 x 42.0 mm, 14 parts (0 on the bottom side), 9 nets.

## KiCad design fs5-telemetry-peripheral-board.kicad_pcb

Board: 2 copper layers, 37 parts (0 on the bottom side), 18 nets, no tracks yet.

Parts:
C1, C2, C3, C4, C5, C6, C11, C12, C13, C14: C; DFN-6-1EP_2x2mm_P0.5mm_EP0.61x1.42mm
C17, C18: 6.8pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20, C21, C23: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
FB1: FCM 1608KF-601T03; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J3: Conn_01x07; DFN-6-1EP_2x2mm_P0.5mm_EP0.61x1.42mm
J2: Conn_01x26; LQFP-48_7x7mm_P0.5mm
J8: FTSH-107-01-F-DV-K-P-TR; PinHeader_2x07_P1.27mm_Vertical_SMD
R3, R4, R5, R6, R8, R9, R10, R11, R12: R; DIP-8_W7.62mm
U3: STM32G441KBTx; LQFP-32_7x7mm_P0.8mm
U7, U8: MCP1703AT-3302E/CB; SOT-23
U12: INA826AIDR; SOIC-8_3.9x4.9mm_P1.27mm
U13: REF35160QDBVR; SOT-23-6
Y1: ECS-240-8-37B-CKY-TR; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3_A: C22.1, C23.1, FB1.2
/Vin+: R6.1, R10.1
/Vin-: R4.2, R5.1, R9.1
Brake_Temp_Sense_GND: C1.2, C2.1, C3.2, C4.1, C5.2, C6.2, C11.2, C12.2, C13.2, C14.2, C17.2, C18.2, C19.1, C20.1, C21.1, C22.2, C23.2, J8.5, J8.7, J8.11, R5.2, R6.2, R12.1, U3.14 (VSSA), U3.16 (VSS), U3.32 (VSS), U7.1 (GND), U8.1 (GND), U12.5 (Vs-), U13.1 (GND), U13.2 (GND), Y1.2, Y1.4
Brake_Temp_Sense_VDD: C2.2, C4.2, C14.1, U3.1 (VDD), U3.17 (VDD), U8.2 (VO)
unnamed: R8.1, U12.2 (Rg)
unnamed: R8.2, U12.3 (Rg)
unnamed: R11.1, U12.7
unnamed: R12.2, U3.31 (PB8)
unnamed: C17.1, U3.2 (RCC_OSC_IN), Y1.3
unnamed: C18.1, U3.3 (RCC_OSC_OUT), Y1.1
unnamed: R10.2, U12.4 (+)
unnamed: R9.2, U12.1 (-)
unnamed: U12.6 (Ref), U13.6 (VREF)
Strain_Gauge: R11.2, U3.13 (ADC1_IN15)
Suspension: C6.1, R3.1
Suspension_Travel_VDD: C3.1, C5.1, C12.1, C19.2, C20.2, C21.2, FB1.1, J8.3, U3.15 (VDDA), U7.2 (VO), U12.8 (Vs+), U13.3 (EN), U13.4 (VIN)
Wheel_Speed_VDD: C11.1, C13.1, U7.3 (VI), U8.3 (VI)

## KiCad design strain-gauge-triple/strain-gauge-triple.kicad_pcb

Parts:
C1, C2, C3, C4, C7, C8, C9: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C6: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
IC1: TSV914IDT; TSV914IDT-SOIC-14; Manufacturer_Part_Number TSV914IDT; Mouser Part Number 511-TSV914IDT
J1, J2: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
JP1, JP2, JP3: SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1, R2, R6, R7, R10, R11: 350; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R8, R9: 470R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
S1, S2, S3: StrainGaugeAxial; axial-strain-gauge
S4: StrainGaugeReference; radial-strain-gauge
U1: LDK320AM33R; LDK320AM33R-SOT23-5

Connections:
1V65: C3.2, R3.1; also elsewhere on the board
+3V3: C6.1, U1.5 (OUT); also elsewhere on the board
+3V3_A: C1.1, IC1.4 (VCC+), R1.1, S1.2, S2.2, S3.2, S4.2; also elsewhere on the board
+12V: C5.1, J1.1, J2.1, U1.1 (IN), U1.3 (EN)
/Center_Buffered: IC1.6 (IN2-), IC1.7 (OUT2), JP1.2, R4.1
/Left_Buffered: IC1.13 (IN4-), IC1.14 (OUT4), JP2.2, R8.1
/Reference_Buffered: IC1.1 (OUT1), IC1.2 (IN1-), R5.2
/Right_Buffered: IC1.8 (OUT3), IC1.9 (IN3-), JP3.2, R9.1
Center_Gauge: C2.2, JP1.1, R4.2; also elsewhere on the board
Center_Gauge_Unbuffered: IC1.5 (IN2+), R6.1, S1.1
GND: C1.2, C2.1, C3.1, C4.1, C5.2, C6.2, C7.1, C8.2, C9.1, J1.7, J2.7, R2.2, R6.2, R7.2, R10.2, R11.2, U1.2 (GND); also elsewhere on the board
Left_Gauge: C7.2, JP2.1, R8.2; also elsewhere on the board
Left_Gauge_Unbuffered: IC1.12 (IN4+), R7.1, S2.1
unnamed: C8.1, IC1.11 (VCC-)
unnamed: R1.2, R2.1, R3.2
Reference_Gauge: C4.2, R5.1; also elsewhere on the board
Reference_Gauge_Unbuffered: IC1.3 (IN1+), R11.1, S4.1
Right_Gauge: C9.2, JP3.1, R9.2; also elsewhere on the board
Right_Gauge_Unbuffered: IC1.10 (IN3+), R10.1, S3.1
SPI_CS: J1.6, J2.6; also elsewhere on the board
SPI_IRQ: J1.2, J2.2; also elsewhere on the board
SPI_SCK: J1.5, J2.5; also elsewhere on the board
SPI_SDI: J1.4, J2.4; also elsewhere on the board
SPI_SDO: J1.3, J2.3; also elsewhere on the board

Notes on the sheet:
Tau = 1/f_sample
1140 + 92 + 4714.28571429 * 5 = ~24,803 uA = ~24mA ADC AVDD + ADC DVDD + Strain Gauges + Reference voltage divider = total current on 3V3
Peripheral Board Input/SPI Daisy Chaining Connector
Operational Amplifier Buffer with Low-Pass Filters
Strain Gauges and Reference Divider
TSV914IDT - $1.15 MCP3564RT-E/ST - $5.44 LDK320AM33R - $0.65 --------------------- Total - 7.24
+3V3 Regulator
Tau = 1/f_sample = 1/20kHz = 0.00005 RC = 0.00005 R = 470R C = 0.0005/470 = 0.0000001064 = ~0.1uF Total current draw of op amp and RCs: 5v/(sqrt(470R^2 + (1/(2 * pi * 20kHz * 0.1uF))^2)) = 10.49mA * 4 = 41.96 mA 5v/(sqrt(10kR^2 + (1/(2 * pi * 1Hz * 100uF))^2)) = 0.5 mA 41.96 mA + 0.5 mA = 42.46 mA

Parts:
C10, C11: C; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
FB1: FerriteBead; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
JP4, JP5: SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
U2: MCP3564R-E/ST; MCP3564R-EST

Connections:
1V65: JP5.2, U2.12 (CH7); also elsewhere on the board
+3V3: FB1.1, U2.20 (DVDD); also elsewhere on the board
+3V3_A: C10.1, C11.1, FB1.2, U2.1 (AVDD), U2.4 (REFIN+/OUT); also elsewhere on the board
Center_Gauge: U2.7 (CH2); also elsewhere on the board
GND: C10.2, C11.2, U2.2 (AGND), U2.3 (REFIN-), U2.19 (DGND); also elsewhere on the board
Left_Gauge: U2.5 (CH0); also elsewhere on the board
unnamed: JP4.2, JP5.1, U2.6 (CH1), U2.8 (CH3), U2.10 (CH5)
Reference_Gauge: JP4.1, U2.11 (CH6); also elsewhere on the board
Right_Gauge: U2.9 (CH4); also elsewhere on the board
SPI_CS: U2.13 (*CS); also elsewhere on the board
SPI_IRQ: U2.17 (*IRQ/MDAT); also elsewhere on the board
SPI_SCK: U2.14 (SCK); also elsewhere on the board
SPI_SDI: U2.15 (SDI); also elsewhere on the board
SPI_SDO: U2.16 (SDO); also elsewhere on the board

Notes on the sheet:
3V3 Filter
MCP3564R ADC

Board: 2 copper layers, 223.0 x 50.0 mm, 37 parts (0 on the bottom side), 25 nets.
